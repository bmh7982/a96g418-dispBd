# Keil uVision project a96t418_application.uvproj, settings and files
target A96T418 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: t418code +hex
  c flags: Optimize=9
  c include: ..\source;..\driver;..\library
  asm include: .\INC
  group source
    ../driver/: startup.a51
    ../source/: main.c debug.c RegisterMap.c user_timer.c led_driver.c touch_config.c user_function.c
  group library_touch
    ../library/: library_touch_V109_20240705.LIB
  group app-driver
    ../driver/: a96T418_usi_i2c.c a96T418_bit.c a96T418_wdt.c delay.c a96T418_usart1_uart.c a96T418_timer2.c a96T418_timer1.c a96T418_gpio.c a96T418_clock.c
  group doc
    ../DOC/: LICENSE.md
